# EPEL request: https://bugzilla.redhat.com/show_bug.cgi?id=2450826

SPECFILE = "${PN}.spec"
RPM_SOURCES_SUBDIR = "."

inherit srpm-intree
