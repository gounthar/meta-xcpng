inherit srpm-intree

RDEPENDS:blktap = "libaio"
