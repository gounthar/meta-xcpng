# busybox from EPEL 10's source RPM (busybox-1.37.0-4.el10_2.src.rpm, unchanged): Kitten has none.
inherit srpm-intree
SRPM_NAME = "busybox"
PACKAGES = "${SRPM_NAME}"
