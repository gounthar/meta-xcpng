inherit srpm-intree

SPECFILE = "SPECS/kernel.spec"
