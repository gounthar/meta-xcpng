inherit srpm-intree

RDEPENDS:opam = "bubblewrap m4"
