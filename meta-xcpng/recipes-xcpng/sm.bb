inherit srpm-intree

RDEPENDS:sm = " \
 device-mapper-multipath \
 libcgroup-tools \
 lvm2 \
 python3-bitarray \
 xcp-ng-release-presets \
"
