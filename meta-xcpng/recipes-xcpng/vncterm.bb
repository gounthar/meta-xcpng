# vncterm for riscv64 (see the spec).
inherit srpm-intree
