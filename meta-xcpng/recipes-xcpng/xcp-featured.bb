# xcp-featured (v6d) for riscv64 (see the spec).
inherit srpm-intree
