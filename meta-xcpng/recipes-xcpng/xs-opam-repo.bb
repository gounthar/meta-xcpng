inherit srpm-intree

RDEPENDS:xs-opam-repo = "opam libev-devel"
