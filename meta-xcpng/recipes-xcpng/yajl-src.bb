# yajl built from AlmaLinux Kitten's own source RPM (yajl-2.1.0-24.el10.src.rpm, unchanged):
# Kitten ships no riscv64 binary for it, and Xen's libxenlight needs it.
inherit srpm-intree
SRPM_NAME = "yajl"
